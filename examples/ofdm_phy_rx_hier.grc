<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_phy_rx_hier</value></param>
<param><key>category</key><value>[OFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>OFDM_Phy_Rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>OFDM_OFDM_PHY_IMPL_cb</key>
<param><key>id</key><value>OFDM_OFDM_PHY_IMPL_cb_0</value></param>
<param><key>Nport</key><value>64</value></param>
<param><key>Occupied_Carriers</key><value></value></param>
<param><key>Pilot_Carriers</key><value></value></param>
</block>
<block>
<key>OFDM_ofdm_frame_sync_bb</key>
<param><key>id</key><value>OFDM_ofdm_frame_sync_bb_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>OFDM_OFDM_PHY_IMPL_cb_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDM_ofdm_frame_sync_bb_0</source_block_id><sink_block_id>OFDM_OFDM_PHY_IMPL_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>OFDM_ofdm_frame_sync_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
